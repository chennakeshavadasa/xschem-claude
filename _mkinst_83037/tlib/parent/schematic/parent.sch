v {xschem version=3.4.8RC file_version=1.3}
C {tlib/child} 0 0 0 0 {}
